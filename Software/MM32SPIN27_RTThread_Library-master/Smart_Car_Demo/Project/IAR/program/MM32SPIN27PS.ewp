# IAR project MM32SPIN27PS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN27PS MindMotion MM32SPIN27PS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DEVICE; USE_IAR
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCIncludePath2: ..\..\CODE; ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\Device\CMSIS\IAR_Core; ..\..\..\Libraries\Device\MM32SPIN2xx_p\Include; ..\..\..\Libraries\Device\MM32SPIN2xx_p\HAL_Lib\Inc; ..\..\..\Libraries\seekfree_libraries; ..\..\..\Libraries\seekfree_libraries\board; ..\..\..\Libraries\seekfree_libraries\common; ..\..\..\Libraries\seekfree_peripheral; ..\..\..\Libraries\rtthread_libraries\bsp; ..\..\..\Libraries\rtthread_libraries\components\finsh; ..\..\..\Libraries\rtthread_libraries\include; ..\..\..\Libraries\rtthread_libraries\include\libc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\Libraries\rtthread_libraries\libcpu
  OBJCOPY.OOCOutputFile: MM32SPIN27PS.srec
  ILINK.IlinkOutputFile: MM32SPIN27PS.out
  ILINK.IlinkIcfFile: MM32SPIN27PS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    ../../../Libraries/seekfree_libraries/board/: board.c board.h
  group CODE
    ../../CODE/: button.c button.h buzzer.c buzzer.h display.c display.h elec.c elec.h encoder.c encoder.h motor.c motor.h timer_pit.c timer_pit.h 本文件夹作用.txt
  group common
    ../../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group doc
    ../../../Libraries/doc/: pin_recommend.txt version.txt
  group MM32_HAL
    ../../../Libraries/Device/MM32SPIN2xx_p/HAL_Lib/Inc/: dtype.h hal_adc.h hal_bkp.h hal_comp.h hal_conf.h hal_crc.h hal_dbg.h hal_device.h hal_div.h hal_dma.h hal_exti.h hal_flash.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_opamp.h hal_pwr.h hal_rcc.h hal_redefine.h hal_spi.h hal_sqrt.h hal_syscfg.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h
    ../../../Libraries/Device/MM32SPIN2xx_p/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group rtthread_components
    ../../../Libraries/rtthread_libraries/components/finsh/: cmd.c finsh.h finsh_api.h msh.c msh.h shell.c shell.h
  group rtthread_inc
    ../../../Libraries/rtthread_libraries/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_signal.h libc_stat.h
    ../../../Libraries/rtthread_libraries/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
  group rtthread_lib
    ../../../Libraries/rtthread_libraries/libcpu/: context_iar.S cpuport.c
  group rtthread_src
    ../../../Libraries/rtthread_libraries/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group seekfree_libraries
    ../../../Libraries/seekfree_libraries/: headfile.h zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_exti.c zf_exti.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group seekfree_peripheral
    ../../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_UART_7725.c SEEKFREE_UART_7725.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group startup
    ../../../Libraries/Device/MM32SPIN2xx_p/Source/IAR_StartAsm/: startup_mm32spin2xx_p_iar.s
    ../../../Libraries/Device/MM32SPIN2xx_p/Source/: system_mm32spin2xx_p.c
  group user_c
    ../../USER/src/: isr.c main.c
  group user_h
    ../../USER/inc/: isr.h
    ../../../Libraries/rtthread_libraries/bsp/: rtconfig.h
